<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>channel_measurement</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cent_freq</value></param>
<param><key>value</key><value>2600e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>usrp_tx</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>"addr=134.147.118.216"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:0 B:0</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>cent_freq</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>cent_freq</value></param>
<param><key>gain1</key><value>15</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>usrp_rx</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>"addr=134.147.118.217"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:0 B:0</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>cent_freq</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>cent_freq</value></param>
<param><key>gain1</key><value>15</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>usrp_tx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_rx</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_rx</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_1</source_block_id><sink_block_id>usrp_tx</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
